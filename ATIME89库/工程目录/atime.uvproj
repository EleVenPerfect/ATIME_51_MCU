# Keil uVision project atime.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: atime +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: atime_main.c
